# Keil uVision project VirtualCOMPort.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RFID +hex
  AfterMake: fromelf --bin --output obj\RFID.bin obj\RFID.axf
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USB_User
    ../Usb/: usb_driver.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_flash.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_ld.s
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group Doc
    ../: readme.txt
  group USER
    ../src/: main.c bluetooth.c file.c hitagS.c menu.c RFID.c text_tab.c DataTransfer.c InternalFlash.c MyShow.c ASCT.C log.c platform.c
  group Middle-Driver
    ../src/: stm32f10x_it.c MyHdriver.c delay.c beep.c key.c spi.c i2c.c DmaQueue.c MyUsart.c flash.c power.c PCF8563.c oled.c HTRC110.c bitbuff.c
  group inc
    ../inc/: ASCT.h beep.h bluetooth.h DataTransfer.h delay.h DmaQueue.h file.h flash.h FONT.H gpio_config.h hitagS.h HTRC110.h hw_config_.h i2c.h InternalFlash.h key.h log.h menu.h MyHdriver.h MyUsart.h oled.h PCF8563.h platform_config_.h power.h RFID.h spi.h stm32f10x_conf.h stm32f10x_it.h uart2.h W25X80.h MyShow.h platform.h
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\inc;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
